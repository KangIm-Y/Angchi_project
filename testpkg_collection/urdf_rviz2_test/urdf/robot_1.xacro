Commit message: color fix

File: testpkg_collection/urdf_rviz2_test/urdf/robot_1.xacro (robot description, xacro)
@@ -16,4 +16,5 @@
                 <box size="1 1 1"/>
             </geometry>
+            <material name="white"/>
         </visual>
     </link>
